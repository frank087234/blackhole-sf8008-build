SRCDATE = "20221013"

require octagon-libs.inc

SRC_URI[md5sum] = "6f214074a463e4c04265fbbec8636d63"
SRC_URI[sha256sum] = "0bae3d5e9621bf959b6e1b00d9a744f2eea61986c0c9e07ff752e84fc13192d5"
