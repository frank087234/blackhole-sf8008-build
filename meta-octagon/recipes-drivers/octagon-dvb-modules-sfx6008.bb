KV = "4.4.176"
SRCDATE = "20221128"

require octagon-dvb-modules-hisi.inc

SRC_URI[md5sum] = "5110b11ce25dc57cd2e65a35f952dbf3"
SRC_URI[sha256sum] = "a97efe6d71de0544222d93b51568f65ab9746cf903c41253aa338f46556c9cb7"
