KV = "4.4.176"
SRCDATE = "20240313"

require octagon-dvb-modules-hisi.inc

SRC_URI[md5sum] = "a3f5675bd7e5e3fb0bec1176ce33e776"
SRC_URI[sha256sum] = "813f721c150fa294b4f05f22d221860895c925b8496be25dc79f66211e65df9d"
