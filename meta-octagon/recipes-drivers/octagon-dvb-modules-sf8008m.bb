KV = "4.4.35"
SRCDATE = "20221108"

require octagon-dvb-modules-hisi.inc

SRC_URI[md5sum] = "a770b5018c65121da3b29ec326b3ab16"
SRC_URI[sha256sum] = "21a14a5783d68fea047f5dacd6a612a0a960e5089368a3e2f665d317436704d0"

