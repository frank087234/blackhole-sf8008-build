# Remove openssl40-no-engine patch — not compatible with this tree's OpenSSL version
SRC_URI:remove = "file://openssl40-no-engine.patch"
